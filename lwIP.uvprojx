# Keil uVision project lwIP.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lwIP
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: D:\Lwip Test;.\lwip_1_4_1(Source Code)\src\include;.\lwip_1_4_1(Source Code)\src\include\ipv4;.\lwip_1_4_1(Source Code)\src\include\lwip
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./: main.c
  group LWIP
    ./lwip_1_4_1(Source Code)/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./lwip_1_4_1(Source Code)/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip_1_4_1(Source Code)/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./lwip_1_4_1(Source Code)/src/netif/: etharp.c slipif.c
    ./: enc28j60.c ethernetif.c lwip.c
  group user_includes
    ./: main.h
software components: CMSIS:CORE 5.4.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:Startup 2.6.3
